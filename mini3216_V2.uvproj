# Keil uVision project mini3216_V2.uvproj, settings and files
target mini3216_v2 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: mini3216_v2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver
  group driver
    ./driver/: TimerPolling.c UART.c DS1302.c 1616.c Font.c
  group main
    ./: main.c
